# Keil uVision project SAL.uvprojx, settings and files
target SAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7
  c misc: --gnu
  c include: ..\Core\CMSIS\core_support;..\Core\CMSIS\device_support;..\Core\StdPeriph_Driver\inc;..\USER\inc;..\SAL\SAL_Middeware\inc;..\SAL\SAL_Driver_Library\inc;..\SAL_Software_Libarary\MPU6050;..\SAL_Software_Libarary\ICM20602;..\SAL_Software_Libarary\MT6816
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../USER/src/: main.cpp at32f403a_407_clock.c at32f403a_407_int.c
  group SAL_Driver_Library
    ../SAL/SAL_Driver_Library/src/: SAL.c SAL_I2C.cpp SAL_SPI.cpp SAL_USART.cpp
  group SAL_Software_Library
    ../SAL_Software_Libarary/MPU6050/: mpu6050.cpp
    ../SAL_Software_Libarary/ICM20602/: icm20602.cpp
    ../SAL_Software_Libarary/MT6816/: mt6816.cpp
  group StdPeriph_Driver
    ../Core/StdPeriph_Driver/src/: at32f403a_407_adc.c at32f403a_407_crm.c at32f403a_407_dma.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c
  group Startup
    ../Core/CMSIS/device_support/: system_at32f403a_407.c startup_at32f403a_407.s
  group SAL_Middleware
    ../SAL/SAL_Middeware/src/: delay.c exint.c gpio.c timer.c pwm.c
