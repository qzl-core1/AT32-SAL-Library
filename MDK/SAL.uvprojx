# Keil uVision project SAL.uvprojx, settings and files
target SAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7
  c misc: --gnu
  c include: ..\BSP\inc;..\Core\cm4\core_support;..\Core\cm4\device_support;..\USER\inc;..\SAL\inc;..\SAL_Software_Libarary\MPU6050;..\SAL_Software_Libarary\ICM20602
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../USER/src/: main.cpp at32f403a_407_clock.c at32f403a_407_int.c
  group BSP
    ../BSP/src/: at32f403a_407_crm.c at32f403a_407_misc.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_adc.c at32f403a_407_exint.c
  group CMSIS
    ../Core/cm4/device_support/: startup_at32f403a_407.s system_at32f403a_407.c
  group SAL_Driver_Library
    ../SAL/src/: SAL.cpp SAL_GPIO.cpp SAL_USART.cpp SAL_I2C.cpp SAL_SPI.cpp
  group SAL_Software_Library
    ../SAL_Software_Libarary/MPU6050/: mpu6050.cpp
    ../SAL_Software_Libarary/ICM20602/: ICM20602.cpp
